# Keil uVision project BLE_UniEmulator_Template.uvprojx, settings and files
target BLE_UniEmulator_Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: BLE_UniEmulator_ESL_LandRoverDiscoverySport +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../SerialProtocol;../SmartLED;../SerialFIFO;../License;../EEPROM;../Crypto_Algorithms;../ESL;../LIN_Slave
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_can.c stm32f1xx_hal_crc.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group SerialProtocol
    ../SerialProtocol/: SerialProtocol.c SerialProtocol.h
  group SmartLED
    ../SmartLED/: SmartLED.c SmartLED.h
  group SerialFIFO
    ../SerialFIFO/: SerialFIFO.c SerialFIFO.h
  group License
    ../License/: License.c License.h
  group EEPROM
    ../EEPROM/: EEPROM.c EEPROM.h
  group Crypto_Algorithms
    ../Crypto_Algorithms/: aes.c aes.h md5.c md5.h sha256.c sha256.h Crypto_Types.h
  group ESL
    ../ESL/: ESL.c ESL.h
  group LIN_Slave
    ../LIN_Slave/: LIN_Slave.c LIN_Slave.h
software components: CMSIS:CORE 5.5.0
