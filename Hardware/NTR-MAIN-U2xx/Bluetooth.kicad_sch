File: Hardware/NTR-MAIN-U2xx/Bluetooth.kicad_sch (KiCad schematic)
At the start: 10 parts

Commit message: update boot and app
Parts:
- renumbered R17 to R36, R17 to R37
