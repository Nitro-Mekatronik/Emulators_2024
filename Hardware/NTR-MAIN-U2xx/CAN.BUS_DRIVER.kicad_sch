File: Hardware/NTR-MAIN-U2xx/CAN.BUS_DRIVER.kicad_sch (KiCad schematic)
At the start: 10 parts

Commit message: update boot and app
Parts:
- renumbered R17 to R11, R17 to R12
